#include "Com_pid.h"
//PID调参：（调参过程见末尾注解）

//俯仰角PID结构体，对应俯仰角的外环：
PID_Struct pitch_pid = {.kp = -7.0, .ki = 0.0, .kd = 0.0};
//Y轴角速度结构体，对应俯仰角的内环：
PID_Struct gyro_y_pid = {.kp = 3.0, .ki = 0.0, .kd = 0.50};

//横滚角PID结构体，对应横滚角的外环：
PID_Struct roll_pid = {.kp = -7.0, .ki = 0.0, .kd = 0.0};
//X轴角速度结构体，对应横滚角的内环：
PID_Struct gyro_x_pid = {.kp = 3.0, .ki = 0.0, .kd = 0.50};

//偏航角PID结构体，对应偏航角的外环：
PID_Struct yaw_pid = {.kp = -4.0, .ki = 0.0, .kd = 0.0};
//Z轴角速度结构体，对应偏航角的内环：
PID_Struct gyro_z_pid = {.kp = -8.0, .ki = 0.0, .kd = -0.60};

//单次PID计算:
void Com_PID_Calc(PID_Struct* pid)
{
    //1.计算误差值 = 目标值 - 测量值
    pid -> err = pid -> measure - pid -> desire;

    //2.计算积分误差 = 积分系数 * 误差值 * 间隔时间
    pid -> integral += pid -> err ;//先将误差值加起来，后面再乘积分系数与间隔时间

    //3.计算微分误差 = (误差值 - 上一次误差值) / 间隔时间
    if(pid -> last_err == 0)//上次误差第一次为0，故第一次不计算微分误差，提高稳定性
    {
        pid -> last_err = pid -> err;
    }

    float der = pid -> err - pid -> last_err;//先将前后两次误差值相减的结果累加，后面再乘微分系数，除积分时间

    //4.计算输出结果 = 比例部分*比例部分系数 + 积分误差部分*积分部分系数 + 微分误差部分*微分部分系数
    pid -> output = (pid -> kp * pid -> err) + (pid -> ki * pid -> integral * PERIOD) + (pid -> kd * der / PERIOD);

    //5.更新上一次误差值
    pid -> last_err = pid -> err;
}

//串级PID计算:
void Com_PID_Calc_chain(PID_Struct* out_pid,PID_Struct* in_pid)
{
    //1. 先计算外环：
    Com_PID_Calc(out_pid);

    //2. 再将外环输出值作为内环目标值：
    in_pid -> desire = out_pid -> output;

    //3. 最后计算内环：
    Com_PID_Calc(in_pid);
}


/**
* @brief 限制电机速度
*
* @param 原速度
* @param 最大速度
* @param 最小速度
* @return 最终速度
*/
int16_t com_limit(int16_t speed, int16_t max_speed, int16_t min_speed)
{
    if(speed >= max_speed)
    {
        return max_speed;
    }
    else if (speed <= min_speed)
    {
        return min_speed;
    }
    else
    {
        return speed;
    }
}

/*
================================================================================
                        【补充原理参考 · 文件末尾备查】
重要提醒：本段仅为原理推导、调参记录，仅供阅读参考。
如果修改上方业务代码逻辑、PID参数，务必同步更新此处描述，避免注释与代码脱节！

-------------------------- 双环PID调参说明--------------------------
说明：双环PID的调参是先调内环再调外环。对于本无人机，外环对应角度，内环对应角速度。调参时要选择合理的极性与绝对值。
极性的不合理会导致PID无法按预期方向调整控制对象的运行，绝对值的不合理会导致过调震荡、超过预期极限、抑制效果不明显等问题
而某组方向的参数过大也会干涉其他方向的PID控制效果。要选用合理的参数才能将控制对象既快又稳地调整到按预期结果运行的状态。
--------------------------PID调参过程逻辑 --------------------------------------------
以俯仰角为例：
1.调整内环kp的值：
经过测试，对于内环，结合App_flight_control_motor中对电机速度的配置得出：
参数为正时会起到反向抑制的效果，即抑制无人机在Y轴上转动（俯仰运动）的趋势，使得无人机按预期保持平稳
而kp参数为负时会起到正向控制的效果，会扩大无人机在Y轴上转动趋势，导致飞行姿态异常。因此内环参数符号选为正。
kp参数的绝对值越大，抑制效果越明显。考虑到合理性，这一步选择内环kp值为3

2.调整外环kp的值：
经过测试，对于外环，参数为负时才能起到反向控制的效果，即回调无人机的俯仰姿势，使得无人机按预期方向飞行而不偏离
故外环参数符号选为负。绝对值越大控制效果越明显，但过高会导致过调震荡。
而为了保证效果，还是更倾向选择稍大的kp值。后续再通过调整微分参数kd来抑制过调震荡。这一步选择外环kp值为-7

3.调整内环kd的值：
由于在PID计算公式中，微分系数kd的值会被除以0.06，所以kd的值要从小的值开始调。绝对值越大，抑制震荡效果越明显。
kd的极性与比例系数kp一致。这里将kd设置为0.50。如果后续要调整，kd的值需要与kp的值同比例缩放调整。

4.总结：
通过观察以上三步每一步调整参数的结果，发现到第3步时飞机已经能在Y轴上保持平稳且波动时能及时回调飞行姿态，已经达到目标结果。故后续无需再进行调参
剩余的方向调参过程与逻辑同上，不多赘述。仅需注意的是偏航角的电机加减调整是按对角分组，俯仰角是前后分组，横滚角是左右分组
================================================================================
*/
